# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  AfterMake: fromelf  --bin  --output=led.bin  Objects\LED.axf
  AfterMake: fromelf  --text  -a -c  --output=led.dis  Objects\LED.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c include: .\src;..\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c usart.c string.c task.c
    ./: led.c systick.c
  group start
    ./start/: start.s
  group execption
    ./: exception.c
